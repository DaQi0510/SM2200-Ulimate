# Keil uVision project SM2200-Ultimate.uvprojx, settings and files
target SM2200 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SM2200-Ultimate +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\USER;..\SYSTEM\delay;..\HardWare\LED;..\HardWare\LCD;..\HardWare\SM2200;..\SYSTEM\sys;..\SYSTEM\time;..\HardWare\W5200;..\HardWare\AT24C02;..\Check;..\HardWare\UART;..\HardWare\SendReceive;D:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP;..\HardWare\WWDG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c main.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_wwdg.c
  group HardWare
    ../HardWare/LED/: LED.c
    ../HardWare/LCD/: LCD.c
    ../HardWare/SM2200/: SM2200.c
    ../HardWare/W5200/: W5200.c
    ../HardWare/AT24C02/: AT24C02.c
    ../HardWare/UART/: UART.c
    ../HardWare/WWDG/: wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/time/: time.c
  group Check
    ../Check/: SelfTest.c OPTest.c NetCheck.c DeviceToDevice.c Poll.c
    ../HardWare/: Simulation.c
    ../HardWare/SendReceive/: SendReceive.c
